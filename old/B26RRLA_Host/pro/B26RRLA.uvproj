# Keil uVision project B26RRLA.uvproj, settings and files
target B26RRLA (MCS-51)
  device: SC92F8362B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: B26RRLA +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group bsp
    ../bsp/: bsp_led.c bsp_timer.c bsp_uart.c bsp_btm.c bsp_key.c
  group lib
    ../lib/: S_TouchKeyCFG.C SC92F8X6XB_HighSensitive_Lib_T1_V1.0.5.LIB
  group TimeOut
    ../TimeOut/: TimeOut.c
