# Keil uVision project B26_ALL_2018.03.12.uvproj, settings and files
target B26RRLA (MCS-51)
  device: SC92F8362B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: B26_ALL_2018.02.03 +hex
  c flags: Optimize=2 SizeSpeed=1
  c include: .\H;.\lib
  group starup
    ./: STARTUP.A51
  group user
    ./C/: main.c SYSTEM.C
  group bsp
    ./C/: function.c INIT.C key.c UART.C
  group lib
    ./lib/: S_TouchKeyCFG.C SC92F8X6XB_HighSensitive_Lib_T1_V1.0.5.LIB
  group TimeOut
    ./C/: TimeOut.c
